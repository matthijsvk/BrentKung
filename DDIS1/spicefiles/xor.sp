**********************************
**** NOR: simple example
**********************************

* Simulation setup
*------------------
*Some simulation options
.options post nomod
.option opts fast parhier=local
.options captab

*Add the 45nm CMOS library. NORice how the path is generated by MATLAB
.lib '/users/start2016/r0364010/Master2/DDIS/DDIS1/Resources/Technology/tech_wrapper.lib ' tt

*Add the .vec file
.vec '/users/start2016/r0364010/Master2/DDIS/DDIS1/m2sfiles/nor.vec'

.tran 0.001n 10n *Do a transient simulation, final time = 5ns
.probe v i

.param supply = 1

* Voltage sources -> inputs are now provided in the .vec files, so disable them here
*-----------------
* name pin1 pin2 type
* pulseparameters:(init, pulsedVal, delay, rise, fall, pulse width, period)
*Vin1 in1  vss pulse 0 supply 0.99p 20p 20p 2n 3n
*Vin2 in2  vss pulse 0 supply 0.99p 20p 20p 1n 2n

Vdd vdd vss supply
Vss vss 0 0

* Simulated circuit
*-------------------
*Creation of a XOR gate in the circuit

* many XOR gates:
xXOR1 in1 in2 out vdd vss MYXOR multfac=1

 * add a capacitor
*Cap out vss 10f

* Subcircuits
*-------------
 .SUBCKT MYXOR inputA inputB  output vdd vss multfac='1'
*    drain  gate   src  bulk
    xMNA n1  	 inputA  vss vss MOSN w='multfac*2*120e-9' l='45e-9'
    xMNB output  inputB  n1 vss MOSN w='multfac*2*120e-9' l='45e-9'

    xMPA inputB  inputA  output vdd MOSP w='multfac*4*120e-9' l='45e-9'
    xMPB n1  inputB  output vdd MOSP w='multfac*4*120e-9' l='45e-9'
 .ENDS MYXOR

  .SUBCKT MYXNOR inputA inputB  output vdd vss multfac='1'
*    drain  gate   src  bulk
    xMNA output  inputA  inputB vss MOSN w='multfac*2*120e-9' l='45e-9'
    xMNB output  inputB  inputA vss MOSN w='multfac*2*120e-9' l='45e-9'

    xMPA n1  inputA  vss vdd MOSP w='multfac*4*120e-9' l='45e-9'
    xMPB output  inputB  n1 vdd MOSP w='multfac*4*120e-9' l='45e-9'
 .ENDS MYXNOR

.END
