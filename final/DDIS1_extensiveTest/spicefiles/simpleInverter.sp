**********************************
**** INVERTER: simple example
**********************************

* Simulation setup
*------------------
*Some simulation options
.options post nomod
.option opts fast parhier=local
.options captab

*Add the 45nm CMOS library. Notice how the path is generated by MATLAB
.lib '/users/start2016/r0364010/Master2/DDIS/DDIS1/Resources/Technology/tech_wrapper.lib ' tt

.tran 0.001n 5n *Do a transient simulation, final time = 5ns
.probe v i

.param supply = 1

* Voltage sources
*-----------------
Vin in  vss pulse 0 supply 0.99p 20p 20p 1n 2n
Vdd vdd vss supply
Vss vss 0 0

* Simulated circuit
*-------------------
*Creation of a NOT gate in the circuit
* just one NOT gate:
Xnot1 in out vdd vss MYNOT

* many NOT gates:
*Xnot1 in n1 vdd vss MYNOT
*Xnot2 n1 out vdd vss MYNOT multfac=16

 * add a capacitor
*Cout out vss 10f

* Subcircuits
*-------------
.SUBCKT MYNOT input output vdd vss multfac='1000'
xM1 output input vss vss MOSN w='multfac*120e-9' l='45e-9'
xM2 output input vdd vdd MOSP w='multfac*2*120e-9' l='45e-9'
.ENDS MYNOT

.END
